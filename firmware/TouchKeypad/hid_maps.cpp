#include "hid_maps.h"

struct KeyMapEntry { const char *name; uint8_t hid; };
static const KeyMapEntry keyMap[] = {
  { "A", 0x04 }, { "B", 0x05 }, { "C", 0x06 }, { "D", 0x07 }, { "E", 0x08 }, { "F", 0x09 }, { "G", 0x0A }, { "H", 0x0B },
  { "I", 0x0C }, { "J", 0x0D }, { "K", 0x0E }, { "L", 0x0F }, { "M", 0x10 }, { "N", 0x11 }, { "O", 0x12 }, { "P", 0x13 },
  { "Q", 0x14 }, { "R", 0x15 }, { "S", 0x16 }, { "T", 0x17 }, { "U", 0x18 }, { "V", 0x19 }, { "W", 0x1A }, { "X", 0x1B },
  { "Y", 0x1C }, { "Z", 0x1D }, { "1", 0x1E }, { "2", 0x1F }, { "3", 0x20 }, { "4", 0x21 }, { "5", 0x22 }, { "6", 0x23 },
  { "7", 0x24 }, { "8", 0x25 }, { "9", 0x26 }, { "0", 0x27 }, { "ENTER", 0x28 }, { "ESC", 0x29 }, { "BACKSPACE", 0x2A },
  { "TAB", 0x2B }, { "SPACE", 0x2C }, { "MINUS", 0x2D }, { "EQUAL", 0x2E }, { "LEFT_BRACE", 0x2F }, { "RIGHT_BRACE", 0x30 },
  { "BACKSLASH", 0x31 }, { "SEMICOLON", 0x33 }, { "QUOTE", 0x34 }, { "TILDE", 0x35 }, { "COMMA", 0x36 }, { "DOT", 0x37 },
  { "SLASH", 0x38 }, { "CAPS_LOCK", 0x39 }, { "F1", 0x3A }, { "F2", 0x3B }, { "F3", 0x3C }, { "F4", 0x3D }, { "F5", 0x3E },
  { "F6", 0x3F }, { "F7", 0x40 }, { "F8", 0x41 }, { "F9", 0x42 }, { "F10", 0x43 }, { "F11", 0x44 }, { "F12", 0x45 },
  { "PRINT_SCREEN", 0x46 }, { "SCROLL_LOCK", 0x47 }, { "PAUSE", 0x48 },
  { "INSERT", 0x49 }, { "HOME", 0x4A }, { "PAGEUP", 0x4B }, { "DELETE", 0x4C }, { "END", 0x4D }, { "PAGEDOWN", 0x4E },
  { "RIGHT_ARROW", 0x4F }, { "LEFT_ARROW", 0x50 }, { "DOWN_ARROW", 0x51 }, { "UP_ARROW", 0x52 },
  { "F13", 0x68 }, { "F14", 0x69 }, { "F15", 0x6A }, { "F16", 0x6B }, { "F17", 0x6C }, { "F18", 0x6D },
  { "F19", 0x6E }, { "F20", 0x6F }, { "F21", 0x70 }, { "F22", 0x71 }, { "F23", 0x72 }, { "F24", 0x73 },
  { nullptr, 0 }
};

struct ModMapEntry { const char *name; uint8_t bit; };
static const ModMapEntry modMap[] = {
  { "LEFT_CTRL", 0x01 }, { "LEFT_SHIFT", 0x02 }, { "LEFT_ALT", 0x04 }, { "LEFT_GUI", 0x08 },
  { "RIGHT_CTRL", 0x10 }, { "RIGHT_SHIFT", 0x20 }, { "RIGHT_ALT", 0x40 }, { "RIGHT_GUI", 0x80 },
  { nullptr, 0 }
};

struct MediaMapEntry { const char *name; uint16_t code; };
static const MediaMapEntry mediaMap[] = {
  { "PLAY_PAUSE", 0xCD }, { "STOP", 0xB7 }, { "NEXT", 0xB5 }, { "PREVIOUS", 0xB6 },
  { "MUTE", 0xE2 }, { "VOLUME_UP", 0xE9 }, { "VOLUME_DOWN", 0xEA }, { nullptr, 0 }
};

uint8_t keyNameToHid(const char *s) {
  for (int i = 0; keyMap[i].name; ++i)
    if (!strcasecmp(s, keyMap[i].name)) return keyMap[i].hid;
  return 0;
}

uint8_t modifierNameToBit(const char *s) {
  for (int i = 0; modMap[i].name; ++i)
    if (!strcasecmp(s, modMap[i].name)) return modMap[i].bit;
  return 0;
}

uint16_t mediaNameToCode(const char *s) {
  for (int i = 0; mediaMap[i].name; ++i)
    if (!strcasecmp(s, mediaMap[i].name)) return mediaMap[i].code;
  return 0;
}

// Printable ASCII 0x20..0x7E -> usage; bit 7 set = needs shift (US layout).
static const uint8_t asciiMap[95] = {
  0x2C, 0x9E, 0xB4, 0xA0, 0xA1, 0xA2, 0xA4, 0x34,   //  ! " # $ % & '
  0xA6, 0xA7, 0xA5, 0xAE, 0x36, 0x2D, 0x37, 0x38,   // ( ) * + , - . /
  0x27, 0x1E, 0x1F, 0x20, 0x21, 0x22, 0x23, 0x24,   // 0-7
  0x25, 0x26, 0xB3, 0x33, 0xB6, 0x2E, 0xB7, 0xB8,   // 8 9 : ; < = > ?
  0x9F, 0x84, 0x85, 0x86, 0x87, 0x88, 0x89, 0x8A,   // @ A-G
  0x8B, 0x8C, 0x8D, 0x8E, 0x8F, 0x90, 0x91, 0x92,   // H-O
  0x93, 0x94, 0x95, 0x96, 0x97, 0x98, 0x99, 0x9A,   // P-W
  0x9B, 0x9C, 0x9D, 0x2F, 0x31, 0x30, 0xA3, 0xAD,   // X Y Z [ \ ] ^ _
  0x35, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0A,   // ` a-g
  0x0B, 0x0C, 0x0D, 0x0E, 0x0F, 0x10, 0x11, 0x12,   // h-o
  0x13, 0x14, 0x15, 0x16, 0x17, 0x18, 0x19, 0x1A,   // p-w
  0x1B, 0x1C, 0x1D, 0xAF, 0xB1, 0xB0, 0xB5          // x y z { | } ~
};

bool asciiToHid(char c, uint8_t &code, bool &shift) {
  shift = false;
  if (c == '\n') { code = 0x28; return true; }
  if (c == '\t') { code = 0x2B; return true; }
  if (c == '\b') { code = 0x2A; return true; }
  if (c < 0x20 || c > 0x7E) return false;
  uint8_t v = asciiMap[c - 0x20];
  shift = v & 0x80;
  code = v & 0x7F;
  return true;
}
